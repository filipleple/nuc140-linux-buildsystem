# Keil uVision project SDCard.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: NUC140VE3CN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.1.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: SDCard
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\Library\Device\Nuvoton\NUC1xx\Include;..\..\..\Library\Device\Nuvoton\NUC1xx\Source;.\ff8\src;..\..\..\Library\CMSIS\Include;..\..\..\Library\NUC1xx-LB_002\Include;..\..\..\Library\NUC1xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../../../Library/CMSIS/Include/: core_cm0.c
    ../../../Library/Device/Nuvoton/NUC1xx/Source/: system_NUC1xx.c
    ../../../Library/Device/Nuvoton/NUC1xx/Source/arm/: startup_NUC1xx.s
  group Library
    ../../../Library/NUC1xx/Source/: GPIO.c SPI.c SYS.c UART.c retarget.c
  group User
    ../../../Library/NUC1xx-LB_002/Source/: SDCard.c
    ./ff8/src/: ff.c diskio.c
    ./: main.c
software components: Compiler:I/O:STDOUT 1.2.0
