# IAR project FMC_IAP.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC100DN series Nuvoton NUC100DN series (NUC100DN,NUC120DN)
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\NUC100Series\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: FMC_IAP.bin
  ILINK.IlinkOutputFile: FMC_IAP.out
  ILINK.IlinkIcfFile: FMC_IAP.icf
  ILINK.IlinkExtraOptions: --image_input Release\Exe\FMC_IAP_LD.bin,loaderImageBase,.bin_image,4; --image_input Release\Exe\FMC_IAP_LD.bin,loaderImageLimit,.bin_image,4
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC100Series/Source/IAR/: startup_NUC100Series.s
    ../../../../Library/Device/Nuvoton/NUC100Series/Source/: system_NUC100Series.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c uart.c
  group User
    ../: main.c
