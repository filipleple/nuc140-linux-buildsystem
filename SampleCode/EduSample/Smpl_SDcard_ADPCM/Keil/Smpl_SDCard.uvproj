# Keil uVision project Smpl_SDCard.uvproj, settings and files
target Smpl_SDCard (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: NUC140VE3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Smpl_SDCard
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\;..\ff8\src\;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC1xx\Include;..\..\..\..\Library\Device\Nuvoton\NUC1xx\Source;..\..\..\..\Library\;..\..\..\..\Library\NUC1xx\Include;..\..\..\..\Library\NUC1xx-LB_002\Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../../../../Library/CMSIS/Include/: core_cm0.c
    ../../../../Library/Device/Nuvoton/NUC1xx/Source/: system_NUC1xx.c
    ../../../../Library/Device/Nuvoton/NUC1xx/Source/arm/: startup_NUC1xx.s
  group Source files
    ../: main.c
    ../ff8/src/: diskio.c ff.c
    ../../../../Library/NUC1xx-LB_002/Source/: LCD.c SDCard.c
    ../../../../Library/NUC1xx/Source/: retarget.c
  group Library files
    ../: libImaAdpcm4bit.lib
    ../../../../Library/NUC1xx/Source/: GPIO.c SYS.c SPI.c I2C.c I2S.c UART.c
